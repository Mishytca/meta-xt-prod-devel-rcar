SRC_URI:remove = " file://0001-hack-use-weston-13.patch "

SRCREV = "4c7d574af5cfba7a06c6d5575ee699ee8381fab8"
