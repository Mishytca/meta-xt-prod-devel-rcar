SRC_URI:remove = " \
    file://0004-plat-renesas-rcar-Add-R-Car-V3H-support.patch \
"
