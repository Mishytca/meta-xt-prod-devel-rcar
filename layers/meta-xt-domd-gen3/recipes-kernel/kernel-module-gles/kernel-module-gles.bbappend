EXTRA_OEMAKE:append = ' KBUILD_CFLAGS+=" -Wno-error=enum-conversion" KCFLAGS+=" -Wno-error=enum-conversion"'
